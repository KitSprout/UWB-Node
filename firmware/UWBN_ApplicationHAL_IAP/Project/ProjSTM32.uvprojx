# Keil uVision project ProjSTM32.uvprojx, settings and files
target STM32F411C (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F411C
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, USE_FULL_LL_DRIVER, ARM_MATH_CM4, STM32F411xE
  c include: ..\Libraries\CMSIS\Device;..\Libraries\CMSIS\DSP_Lib;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\Libraries\STM32F4xx_HAL_Driver\Inc\Legacy;..\Program;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../Libraries/CMSIS/Device/: startup_stm32f411xe.s system_stm32f4xx.c
  group Library
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c
    ../Program/: stm32f4xx_hal_conf.h
  group Driver
    ../Program/drivers/: stm32f4_msp.c stm32f4_delay.c stm32f4_flash.c stm32f4_tim.c stm32f4_uart.c
    ../Program/: boardConfig.h
  group Program
    ../Program/: main.c stm32f4xx_bsp.c stm32f4xx_it.c
  group Module
    ../Program/modules/: serial.c kSerial.c
  group Algorithm
    ../Program/algorithms/: string.c
software components: CMSIS:CORE 5.0.1
